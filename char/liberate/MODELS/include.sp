*
.LIB 'sm141064.hspice' nmos_3p3_t
.LIB 'sm141064.hspice' pmos_3p3_t
